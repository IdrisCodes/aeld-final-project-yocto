inherit externalsrc
EXTERNALSRC = "/home/idris/Projects/Coursera/EmbeddedLinux/Course3/final-project-IdrisCodes/DoorUnlockerServer"
